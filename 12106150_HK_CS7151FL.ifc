Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-11-08T07:58:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 08 07:58:00 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\1ef60af6-018b-4acc-a16c-07ab04120d07\62892356-d7dc-434b-ad5c-63a1e70ff4c8\ifc * Database version: 5507 * Database creation date: Tue Nov 08 07:57:56 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 08 07:57:57 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 08 07:57:57 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12106150_HK_CS7151FL:27715150_HK_12106150_CS7151FL, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 27715150_HK_12106150_CS7151FL
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 27715150_HK_12106150_CS7151FL
Type - Pset_ProvisionForVoid - Depth: 520 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Cast, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Connection_Gas
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 288 mm; Height: 92 mm
